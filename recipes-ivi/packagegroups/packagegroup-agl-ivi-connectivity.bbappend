
RDEPENDS_${PN}_remove_mx6 += "\
    rtl-sdr \
    "
