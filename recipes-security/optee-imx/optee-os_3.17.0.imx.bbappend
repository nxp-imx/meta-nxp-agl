FILES:${PN} += " ${nonarch_base_libdir}/optee_armtz/"