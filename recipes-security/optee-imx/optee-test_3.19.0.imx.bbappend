FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Makefile-Use-bindir-and-libdir-from-toolchain.patch"
