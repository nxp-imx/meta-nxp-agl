
RDEPENDS_${PN} += "\
    ces2016-demo \
    qtmultimedia-plugins \
    "
