PACKAGECONFIG_IMX_REMOVALS = "x11"