RDEPENDS_${PN}_remove = "qtdeclarative-plugins"
